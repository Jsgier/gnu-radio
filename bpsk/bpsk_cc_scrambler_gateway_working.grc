options:
  parameters:
    author: J. Gier
    generate_options: no_gui
    id: BPSK_Mod_Demod
    output_language: python
    title: BPSK Modulator / Demodulator
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    comment: This is the CCSDS access code
    value: 0o00011010110011111111110000011101
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: cc_dec_def
  id: variable_cc_decoder_def
  parameters:
    framebits: 'frame_size  * 8 '
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[-109,79]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: cc_enc_def
  id: variable_cc_encoder_def
  parameters:
    framebits: 'frame_size * 8 '
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[-109,79]'
    rate: '2'
    state_start: '0'
  states: {}
- name: decode_bits
  id: variable
  parameters:
    value: int(frame_bits/8)
  states: {}
- name: delay_bit
  id: variable
  parameters:
    value: '24'
  states: {}
- name: delay_byte
  id: variable
  parameters:
    value: '33'
  states: {}
- name: delay_constellation
  id: variable
  parameters:
    value: '32'
  states: {}
- name: depth
  id: variable
  parameters:
    value: '1'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.250'
  states: {}
- name: first_root
  id: variable
  parameters:
    value: '112'
  states: {}
- name: format_key
  id: variable
  parameters:
    value: '"protocol_packet"'
  states: {}
- name: frame_bits
  id: variable
  parameters:
    value: frame_bytes*8
  states: {}
- name: frame_bytes
  id: variable
  parameters:
    value: payload_coded_len* depth
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: '2072'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Freq Offset'
    start: '-100e-2 * (1/samp_rate)'
    step: 10e-2 * (1/samp_rate)
    stop: 100e-2 * (1/samp_rate)
    value: '0'
  states: {state: disabled}
- name: gen_poly
  id: variable
  parameters:
    value: '285'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"frame_len"'
  states: {}
- name: len_tag_key_bits
  id: variable
  parameters:
    value: '"frame_len_bits"'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '100e-3'
    stop: '500e-3'
    value: '10E-3'
  states: {state: disabled}
- name: nroots
  id: variable
  parameters:
    value: '32'
  states: {}
- name: payload_coded_len
  id: variable
  parameters:
    value: payload_len_int + 32
  states: {}
- name: payload_len_int
  id: variable
  parameters:
    value: '223'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: 2*3.14/100
  states: {}
- name: prim_element
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, nfilts*11*sps)
  states: {}
- name: rs_generator
  id: variable
  parameters:
    comment: int 391 = 0x187, which is CCSDS rs poly generator
    value: '291'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20E6
  states: {}
- name: sink_address
  id: variable
  parameters:
    value: '"tcp://127.0.0.1:5556"'
  states: {}
- name: source_address
  id: variable
  parameters:
    value: '"tcp://127.0.0.1:5555"'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    label: 'Channel: time offset'
    start: '0.999'
    step: '100e-6'
    stop: '1.001'
    value: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1_0_0_1_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1_0_0_1_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_2_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: delay_bit
    type: byte
  states: {state: disabled}
- name: blocks_delay_1_0
  id: blocks_delay
  parameters:
    delay: delay_byte
    type: byte
  states: {state: disabled}
- name: blocks_delay_2
  id: blocks_delay
  parameters:
    delay: delay_constellation
    type: byte
  states: {state: disabled}
- name: blocks_delay_3
  id: blocks_delay
  parameters:
    comment: Modify for byte alignment
    delay: '3'
    type: complex
  states: {}
- name: blocks_message_debug_0_1_0_0
  id: blocks_message_debug
  parameters:
    alias: Output
  states: {state: disabled}
- name: blocks_message_debug_0_1_0_0_0
  id: blocks_message_debug
  parameters:
    alias: Input
  states: {}
- name: blocks_pack_k_bits_bb_1_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_1_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_tagged_stream_align_1
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: '"frame_len"'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_2_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_2_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: 0o00011010110011111111110000011101
    tagname: CCSDS_frame
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    use_snr: 'True'
    w: '0.2'
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    comment: |-
      input - bits
      output - bits
    len: '7'
    mask: '0x9A'
    seed: '0xFF'
  states: {}
- name: digital_map_bb_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '0'
    loop_bw: excess_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    comment: |-
      input - bits
      output - bits
    len: '7'
    mask: '0x9A'
    seed: '0xFF'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          PDU block that prepends the CCSDS ASM (0x1A CF FC 1D) to each PDU payload.
          Input:  PDU (meta, u8vector)
          Output: PDU (same meta, ASM + payload)
          """

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="prepend_ccsds_asm_pdu",
                  in_sig=None,
                  out_sig=None,
              )

              # CCSDS ASM: 0x1A CF FC 1D
              self._asm = bytes([0x1A, 0xCF, 0xFC, 0x1D])

              # Register PDU ports
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.message_port_register_out(pmt.intern("out"))

          def handle_msg(self, msg):
              """
              msg is a PDU: (meta, data)
              meta: PMT dictionary (or PMT_NIL)
              data: PMT u8vector
              """
              # Split into metadata and data
              meta = pmt.car(msg)
              data = pmt.cdr(msg)

              if not pmt.is_u8vector(data):
                  # Not what we expect; ignore
                  return

              # Convert u8vector to Python bytes
              in_bytes = bytes(bytearray(pmt.u8vector_elements(data)))

              # Prepend ASM
              out_bytes = self._asm + in_bytes

              # Convert back to u8vector
              out_vec = pmt.init_u8vector(len(out_bytes), list(out_bytes))

              # Preserve metadata (you could also modify meta here if needed)
              out_pdu = pmt.cons(meta, out_vec)

              # Publish on output port
              self.message_port_pub(pmt.intern("out"), out_pdu)
    comment: Confirmed that ASM being appended.
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr
      import time
      import threading

      class TestPatternSource_PDU(gr.basic_block):
          """
          Periodically emits PDUs with a simple test pattern:
          [seq_hi][seq_lo][payload bytes...]

          - seq: 16-bit counter
          - payload filled with pattern (e.g. incrementing or 0xAA/0x55)
          """

          def __init__(self, payload_len=200, interval_ms=100):
              gr.basic_block.__init__(self,
                  name="TestPatternSource_PDU",
                  in_sig=None,
                  out_sig=None)

              self.payload_len = int(payload_len)
              self.interval = float(interval_ms) / 1000.0
              self.seq = 0

              self.message_port_register_out(pmt.intern('out'))

              # start worker thread
              self._stop = False
              self.thread = threading.Thread(target=self._worker)
              self.thread.daemon = True
              self.thread.start()

          def stop(self):
              self._stop = True
              try:
                  self.thread.join(timeout=0.1)
              except:
                  pass
              return super().stop()

          def _make_payload(self):
              # 2-byte sequence number + payload_len-2 bytes of pattern
              payload = bytearray(self.payload_len)
              seq = self.seq & 0xFFFF
              payload[0] = (seq >> 8) & 0xFF
              payload[1] = seq & 0xFF

              # simple pattern: incrementing bytes
              ## simpler pattern enabled: same byte every time. 
              for i in range(1, self.payload_len):
                  payload[i] = (i + seq) & 0xFF
                  #payload[i] = (i) & 0xFF

              #self.seq = (self.seq + 1) & 0xFFFF
              self.seq = (self.seq) & 0xFFFF
              return payload

          def _worker(self):
              while not self._stop:
                  payload = self._make_payload()
                  meta = pmt.make_dict()  # empty metadata

                  vec = pmt.init_u8vector(len(payload), payload)
                  pdu = pmt.cons(meta, vec)

                  self.message_port_pub(pmt.intern('out'), pdu)
                  time.sleep(self.interval)
    interval_ms: '100'
    payload_len: payload_len_int
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy
      import pmt
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Stream block that watches for 'CCSDS_frame' tags and injects a
          'frame_len' tag with value frame_len at the **same** offset.

          Assumes:
            - Input and output are uint8 bits (0/1), 1 bit per item.
            - frame_len is in items (bits).
          """

          def __init__(self, frame_len=2072, verbose=False):
              gr.sync_block.__init__(
                  self,
                  name="frame_len_from_ccsds_tag",
                  in_sig=[numpy.uint8],
                  out_sig=[numpy.uint8],
              )

              self.key_ccsds_frame = pmt.intern("CCSDS_frame")
              self.key_frame_len   = pmt.intern("frame_len")

              self.frame_len       = int(frame_len)
              self.frame_len_value = pmt.from_long(self.frame_len)

              self.verbose = bool(verbose)

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]

              # Pass-through
              out[:] = inp

              nread    = self.nitems_read(0)
              nwritten = self.nitems_written(0)
              nitems   = len(inp)

              # Get tags in this input window
              tags = self.get_tags_in_window(0, 0, nitems)

              for t in tags:
                  if t.key == self.key_ccsds_frame:
                      # Absolute offset where CCSDS_frame tag occurred
                      abs_in_offset = t.offset

                      # Relative index within this work() buffer
                      rel_index = abs_in_offset - nread

                      if 0 <= rel_index < nitems:
                          abs_out_offset = nwritten + rel_index

                          # Add frame_len tag at the **same** logical offset
                          self.add_item_tag(
                              0,
                              abs_out_offset,
                              self.key_frame_len,
                              self.frame_len_value,
                              t.srcid
                          )

                          if self.verbose:
                              print(
                                  "[frame_len_from_ccsds_tag] CCSDS_frame at {}, "
                                  "frame_len tag at {}, len={}".format(
                                      int(abs_in_offset), int(abs_out_offset), self.frame_len
                                  )
                              )

              return nitems
    frame_len: frame_len
    verbose: 'True'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          PDU block that strips the CCSDS ASM (0x1A CF FC 1D) from the END of each PDU.

          Input:  PDU (meta, u8vector) = [payload ... ASM]
          Output: PDU (meta, u8vector) = [payload ...]

          If ASM is not found at the end, the PDU is dropped.
          """

          def __init__(self, verbose=False):
              gr.basic_block.__init__(
                  self,
                  name="strip_ccsds_asm_pdu_end",
                  in_sig=None,
                  out_sig=None,
              )

              self._asm = bytes([0x1A, 0xCF, 0xFC, 0x1D])
              self.verbose = verbose

              # Register ports
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.message_port_register_out(pmt.intern("out"))

          def handle_msg(self, msg):
              meta = pmt.car(msg)
              data = pmt.cdr(msg)

              if not pmt.is_u8vector(data):
                  if self.verbose:
                      print("[strip_ccsds_asm_pdu_end] Non-u8vector PDU, dropping.")
                  return

              in_bytes = bytes(bytearray(pmt.u8vector_elements(data)))
              length = len(in_bytes)

              if length < 4:
                  if self.verbose:
                      print(f"[strip_ccsds_asm_pdu_end] PDU too short (len={length}), dropping.")
                  return

              # Extract last 4 bytes (expected location of ASM)
              asm_bytes = in_bytes[-4:]

              if asm_bytes != self._asm:
                  if self.verbose:
                      print(
                          "[strip_ccsds_asm_pdu_end] ASM mismatch, dropping. "
                          f"Got {asm_bytes.hex()}, expected {self._asm.hex()}"
                      )
                  return

              if self.verbose:
                  print(
                      "[strip_ccsds_asm_pdu_end] ASM match at END. "
                      f"Found {asm_bytes.hex()}"
                  )

              # Everything except the last 4 bytes (the ASM)
              out_bytes = in_bytes[:-4]

              # Convert back to u8vector
              out_vec = pmt.init_u8vector(len(out_bytes), list(out_bytes))
              out_pdu = pmt.cons(meta, out_vec)

              # Publish
              self.message_port_pub(pmt.intern("out"), out_pdu)
    verbose: 'True'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          PDU block that takes a u8vector of bits (0/1 per element)
          and packs them into bytes (MSB-first).

          Input:  PDU (meta, u8vector) length = 2072 bits
          Output: PDU (meta, u8vector) length = 259 bytes (2072 / 8)
          """

          def __init__(self, verbose=False):
              gr.basic_block.__init__(
                  self,
                  name="bits_to_bytes_pdu",
                  in_sig=None,
                  out_sig=None,
              )

              self.verbose = verbose

              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.message_port_register_out(pmt.intern("out"))

          def handle_msg(self, msg):
              meta = pmt.car(msg)
              data = pmt.cdr(msg)

              if not pmt.is_u8vector(data):
                  if self.verbose:
                      print("[bits_to_bytes_pdu] Non-u8vector PDU, dropping.")
                  return

              bits = list(pmt.u8vector_elements(data))
              n_bits = len(bits)

              if n_bits % 8 != 0:
                  if self.verbose:
                      print(f"[bits_to_bytes_pdu] Bit length {n_bits} not multiple of 8, dropping.")
                  return

              n_bytes = n_bits // 8
              out_bytes = []

              # Pack 8 bits (b0..b7) into one byte: b0 = MSB
              idx = 0
              for _ in range(n_bytes):
                  byte_val = 0
                  for b in range(8):
                      bit = bits[idx]
                      # Ensure bit is 0/1
                      bit = 1 if bit != 0 else 0
                      byte_val = (byte_val << 1) | bit
                      idx += 1
                  out_bytes.append(byte_val)

              out_vec = pmt.init_u8vector(len(out_bytes), out_bytes)
              out_pdu = pmt.cons(meta, out_vec)
              self.message_port_pub(pmt.intern("out"), out_pdu)
    verbose: 'True'
  states: {}
- name: fec_extended_decoder_0_1_0
  id: fec_extended_decoder
  parameters:
    decoder_list: cc_dec_def
    puncpat: puncpat
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_1_0_0
  id: fec_extended_encoder
  parameters:
    encoder_list: cc_enc_def
    puncpat: puncpat
    threadtype: capillary
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: Frame Size
    type: intx
    value: '100'
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Tagged Stream in Bytes
    tag: '"stream_tag"'
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"frame_len"'
    type: byte
  states: {}
- name: puncpat
  id: parameter
  parameters:
    value: '''11'''
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: costas
    size: '2056'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: sync
    size: '2056'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha2: '0.6'
    label1: Input
    label2: LDPC (alist)
    name: CC compare
    nconnections: '2'
    size: '2048'
    srate: samp_rate
    type: float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha2: '0.6'
    label1: Input
    label2: LDPC (alist)
    name: CC compare byte
    nconnections: '2'
    size: '2048'
    srate: samp_rate
    type: float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: constellation_compare
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: satellites_decode_rs_ccsds_0
  id: satellites_decode_rs_ccsds
  parameters:
    basis: 'False'
    comment: Output length is 223 bytes
    interleave: '1'
  states: {}
- name: satellites_encode_rs_ccsds_0
  id: satellites_encode_rs_ccsds
  parameters:
    basis: 'False'
    comment: Input length must be 223 bytes!
    interleave: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: constel_in
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: message_in
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    comment: input is byte formatted
    stream_id: input
  states: {state: disabled}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: constel_out
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: decoder_out
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: constel_out
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: constel_out
  states: {state: disabled}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: decoder_out
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_1_1_0
  id: virtual_source
  parameters:
    comment: 'Input: Bytes'
    stream_id: input
  states: {state: disabled}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: constel_in
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: constel_in
  states: {state: disabled}
- name: virtual_source_2_0_0
  id: virtual_source
  parameters:
    stream_id: message_in
  states: {}
- name: virtual_source_2_0_0_0
  id: virtual_source
  parameters:
    stream_id: decoder_out
  states: {}
- name: zeromq_pull_msg_source_1
  id: zeromq_pull_msg_source
  parameters:
    address: source_address
    bind: 'True'
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_1
  id: zeromq_push_msg_sink
  parameters:
    address: sink_address
    timeout: '100'
  states: {}

connections:
- [blocks_char_to_float_0_1_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_char_to_float_0_1_0_0_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [blocks_char_to_float_0_1_0_0_1_0_1, '0', qtgui_time_sink_x_1_0, '1']
- [blocks_char_to_float_0_1_0_0_1_0_1_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_char_to_float_0_1_0_1, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_char_to_float_0_1_0_1_0, '0', qtgui_time_sink_x_0_0_0_0, '1']
- [blocks_char_to_float_0_2_0, '0', fec_extended_decoder_0_1_0, '0']
- [blocks_delay_1, '0', blocks_char_to_float_0_1_0, '0']
- [blocks_delay_1_0, '0', blocks_char_to_float_0_1_0_1, '0']
- [blocks_delay_2, '0', blocks_char_to_float_0_1_0_0_1_0_1_0, '0']
- [blocks_delay_3, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_pack_k_bits_bb_1_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_pack_k_bits_bb_1_0_0_0, '0', blocks_char_to_float_0_1_0_1_0, '0']
- [blocks_tagged_stream_align_1, '0', pdu_tagged_stream_to_pdu_0_0_0_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_3, '0']
- [blocks_unpack_k_bits_bb_2_0, '0', blocks_delay_1, '0']
- [blocks_unpack_k_bits_bb_2_1, '0', digital_scrambler_bb_0, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_2, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', epy_block_1, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_delay_3, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_descrambler_bb_0, '0', virtual_sink_2_0, '0']
- [digital_map_bb_0_0_0_0, '0', blocks_char_to_float_0_2_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_const_sink_x_0_0_0_0, '0']
- [digital_scrambler_bb_0, '0', fec_extended_encoder_1_0_0, '0']
- [epy_block_0, out, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [epy_block_0_0_0, out, satellites_encode_rs_ccsds_0, in]
- [epy_block_1, '0', blocks_tagged_stream_align_1, '0']
- [epy_block_2, out, satellites_decode_rs_ccsds_0, in]
- [epy_block_3, out, epy_block_2, in]
- [fec_extended_decoder_0_1_0, '0', digital_descrambler_bb_0, '0']
- [fec_extended_encoder_1_0_0, '0', virtual_sink_0, '0']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', virtual_sink_0_0, '0']
- [pdu_tagged_stream_to_pdu_0_0_0_0, pdus, epy_block_3, in]
- [satellites_decode_rs_ccsds_0, out, blocks_message_debug_0_1_0_0, print]
- [satellites_decode_rs_ccsds_0, out, blocks_message_debug_0_1_0_0_0, print]
- [satellites_decode_rs_ccsds_0, out, zeromq_push_msg_sink_1, in]
- [satellites_encode_rs_ccsds_0, out, epy_block_0, in]
- [virtual_source_0, '0', digital_map_bb_0_0_0_0, '0']
- [virtual_source_0_0, '0', blocks_char_to_float_0_1_0_0_1_0_1, '0']
- [virtual_source_0_1, '0', blocks_char_to_float_0_1_0_0_0, '0']
- [virtual_source_0_1, '0', blocks_pack_k_bits_bb_1_0_0_0, '0']
- [virtual_source_1, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [virtual_source_1_1_0, '0', blocks_delay_1_0, '0']
- [virtual_source_1_1_0, '0', blocks_unpack_k_bits_bb_2_0, '0']
- [virtual_source_2, '0', blocks_pack_k_bits_bb_1_0, '0']
- [virtual_source_2_0, '0', blocks_delay_2, '0']
- [virtual_source_2_0_0, '0', blocks_unpack_k_bits_bb_2_1, '0']
- [virtual_source_2_0_0, '0', virtual_sink_1_0_0, '0']
- [virtual_source_2_0_0_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [zeromq_pull_msg_source_1, out, satellites_encode_rs_ccsds_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
