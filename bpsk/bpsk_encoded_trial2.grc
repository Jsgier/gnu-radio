options:
  parameters:
    author: J. Gier
    generate_options: qt_gui
    id: BPSK_Mod_Demod
    output_language: python
    title: BPSK Modulator / Demodulator
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: cc_dec_def
  id: variable_cc_decoder_def
  parameters:
    framebits: frame_bits
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'True'
    polys: '[121,91]'
    rate: '2'
    state_end: '0'
    state_start: '0'
  states: {}
- name: cc_enc_def
  id: variable_cc_encoder_def
  parameters:
    framebits: frame_bits
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'True'
    polys: '[121,91]'
    rate: '2'
    state_start: '0'
  states: {}
- name: decode_bits
  id: variable
  parameters:
    value: int(frame_bits/8)
  states: {}
- name: delay
  id: variable
  parameters:
    value: int((1.875*sps+7)*2)
  states: {}
- name: depth
  id: variable
  parameters:
    value: '2'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.220'
  states: {}
- name: first_root
  id: variable
  parameters:
    value: '1'
  states: {}
- name: frame_bits
  id: variable
  parameters:
    value: frame_bytes*8
  states: {}
- name: frame_bytes
  id: variable
  parameters:
    value: payload_coded_len* depth
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Freq Offset'
    start: '-100e-2 * (1/samp_rate)'
    step: 10e-2 * (1/samp_rate)
    stop: 100e-2 * (1/samp_rate)
    value: '0'
  states: {}
- name: gen_poly
  id: variable
  parameters:
    value: '285'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"payload_coded_len"'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '100e-3'
    stop: '500e-3'
    value: '10E-3'
  states: {}
- name: nroots
  id: variable
  parameters:
    value: '32'
  states: {}
- name: packet_len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: payload_coded_len
  id: variable
  parameters:
    value: payload_len_int + 32
  states: {}
- name: payload_len_int
  id: variable
  parameters:
    value: '200'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '62.8e-3'
  states: {}
- name: prim_element
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1, samp_rate, samp_rate/sps, excess_bw, 11*sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    label: 'Channel: time offset'
    start: '0.999'
    step: '100e-6'
    stop: '1.001'
    value: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0_1_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: 232 bytes in, 1856 bits out (as bytes)
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"frame_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: 1856 bits in (as bytes), 232 bytes out
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"frame_len"'
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1,1]'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {state: disabled}
- name: end
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10'
    min: '-10'
    type: byte
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr
      import time
      import threading

      class TestPatternSource_PDU(gr.basic_block):
          """
          Periodically emits PDUs with a simple test pattern:
          [seq_hi][seq_lo][payload bytes...]

          - seq: 16-bit counter
          - payload filled with pattern (e.g. incrementing or 0xAA/0x55)
          """

          def __init__(self, payload_len=200, interval_ms=100):
              gr.basic_block.__init__(self,
                  name="TestPatternSource_PDU",
                  in_sig=None,
                  out_sig=None)

              self.payload_len = int(payload_len)
              self.interval = float(interval_ms) / 1000.0
              self.seq = 0

              self.message_port_register_out(pmt.intern('out'))

              # start worker thread
              self._stop = False
              self.thread = threading.Thread(target=self._worker)
              self.thread.daemon = True
              self.thread.start()

          def stop(self):
              self._stop = True
              try:
                  self.thread.join(timeout=0.1)
              except:
                  pass
              return super().stop()

          def _make_payload(self):
              # 2-byte sequence number + payload_len-2 bytes of pattern
              payload = bytearray(self.payload_len)
              seq = self.seq & 0xFFFF
              payload[0] = (seq >> 8) & 0xFF
              payload[1] = seq & 0xFF

              # simple pattern: incrementing bytes
              for i in range(2, self.payload_len):
                  payload[i] = (i + seq) & 0xFF

              self.seq = (self.seq + 1) & 0xFFFF
              return payload

          def _worker(self):
              while not self._stop:
                  payload = self._make_payload()
                  meta = pmt.make_dict()  # empty metadata

                  vec = pmt.init_u8vector(len(payload), payload)
                  pdu = pmt.cons(meta, vec)

                  self.message_port_pub(pmt.intern('out'), pdu)
                  time.sleep(self.interval)
    interval_ms: '100'
    payload_len: payload_len_int
  states: {}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    comment: 11 Puncture Patttern -> both encoded output bits always kept
    decoder_list: cc_dec_def
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_0_0
  id: fec_extended_encoder
  parameters:
    comment: 11 Puncture Patttern -> both encoded output bits always kept
    encoder_list: cc_enc_def
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'Source: https://wiki.gnuradio.org/index.php?title=QPSK_Mod_and_Demod#Objectives'
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: '"frame_len"'
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"frame_len"'
    type: byte
  states: {}
- name: post_decode
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: byte
  states: {}
- name: pre_encode
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: pre_ch
    size: '2056'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: pre_ch
    size: '2056'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: satellites_decode_rs_0_0
  id: satellites_decode_rs
  parameters:
    comment: 232 bytes in, 200 bytes out
    fcr: first_root
    gfpoly: gen_poly
    interleave: '1'
    nroots: nroots
    nsym: '8'
    prim: prim_element
  states: {}
- name: satellites_encode_rs_0_0
  id: satellites_encode_rs
  parameters:
    comment: 200 bytes in, 232 bytes out
    fcr: first_root
    gfpoly: gen_poly
    interleave: '1'
    nroots: nroots
    nsym: '8'
    prim: prim_element
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: fec_enc
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: fec_enc
  states: {}

connections:
- [blocks_char_to_float_0_0, '0', fec_extended_decoder_0_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', fec_extended_encoder_0_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0_0, '0']
- [blocks_throttle2_0_0_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_throttle2_0_0_0, '0', digital_map_bb_0_0, '0']
- [blocks_throttle2_0_0_0, '0', pre_encode, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', blocks_char_to_float_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', post_decode, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_0_0, '0']
- [epy_block_0_0_0, out, satellites_encode_rs_0_0, in]
- [fec_extended_decoder_0_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [fec_extended_decoder_0_0, '0', end, '0']
- [fec_extended_encoder_0_0, '0', virtual_sink_2, '0']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [pdu_tagged_stream_to_pdu_0_0_0_0, pdus, satellites_decode_rs_0_0, in]
- [root_raised_cosine_filter_0, '0', qtgui_const_sink_x_0_0_0_0_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [root_raised_cosine_filter_0, '0', root_raised_cosine_filter_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', qtgui_const_sink_x_0_0_0_0_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', qtgui_time_sink_x_0, '0']
- [satellites_decode_rs_0_0, out, blocks_message_debug_0_1_0, print]
- [satellites_encode_rs_0_0, out, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [virtual_source_2, '0', blocks_throttle2_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
