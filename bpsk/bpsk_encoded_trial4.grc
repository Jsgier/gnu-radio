options:
  parameters:
    author: J. Gier
    generate_options: qt_gui
    id: BPSK_Mod_Demod
    output_language: python
    title: BPSK Modulator / Demodulator
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    comment: This is the CCSDS access code
    value: 0o00011010110011111111110000011101
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: decode_bits
  id: variable
  parameters:
    value: int(frame_bits/8)
  states: {}
- name: depth
  id: variable
  parameters:
    value: '1'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.350'
  states: {}
- name: first_root
  id: variable
  parameters:
    value: '112'
  states: {}
- name: format_key
  id: variable
  parameters:
    value: '"protocol_packet"'
  states: {}
- name: frame_bits
  id: variable
  parameters:
    value: frame_bytes*8
  states: {}
- name: frame_bytes
  id: variable
  parameters:
    value: payload_coded_len* depth
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Freq Offset'
    start: '-100e-2 * (1/samp_rate)'
    step: 10e-2 * (1/samp_rate)
    stop: 100e-2 * (1/samp_rate)
    value: '0'
  states: {}
- name: gen_poly
  id: variable
  parameters:
    value: '285'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"frame_len"'
  states: {}
- name: len_tag_key_bits
  id: variable
  parameters:
    value: '"frame_len_bits"'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '100e-3'
    stop: '500e-3'
    value: '0'
  states: {}
- name: nroots
  id: variable
  parameters:
    value: '32'
  states: {}
- name: payload_coded_len
  id: variable
  parameters:
    value: payload_len_int + 32
  states: {}
- name: payload_len_int
  id: variable
  parameters:
    value: '223'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: 2*3.14/100
  states: {}
- name: prim_element
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 11*sps*nfilts)
  states: {}
- name: rs_generator
  id: variable
  parameters:
    comment: int 391 = 0x187, which is CCSDS rs poly generator
    value: '291'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    label: 'Channel: time offset'
    start: '0.999'
    step: '100e-6'
    stop: '1.001'
    value: '1'
  states: {}
- name: blocks_message_debug_0_1_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_1_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_tag_debug_0_0_0
  id: blocks_tag_debug
  parameters:
    filter: CCSDS_frame
    name: output_tag
    type: byte
  states: {}
- name: blocks_tag_debug_0_0_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"frame_len"'
    name: output_frame_tag
    type: byte
  states: {}
- name: blocks_tagged_stream_align_1
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: '"frame_len"'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: This block also does RRC filtering
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
    truncate: 'True'
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: bpsk
    npwr: '-1'
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: 0o00011010110011111111110000011101
    tagname: CCSDS_frame
    threshold: '3'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '8'
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          PDU block that prepends the CCSDS ASM (0x1A CF FC 1D) to each PDU payload.
          Input:  PDU (meta, u8vector)
          Output: PDU (same meta, ASM + payload)
          """

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="prepend_ccsds_asm_pdu",
                  in_sig=None,
                  out_sig=None,
              )

              # CCSDS ASM: 0x1A CF FC 1D
              self._asm = bytes([0x1A, 0xCF, 0xFC, 0x1D])

              # Register PDU ports
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.message_port_register_out(pmt.intern("out"))

          def handle_msg(self, msg):
              """
              msg is a PDU: (meta, data)
              meta: PMT dictionary (or PMT_NIL)
              data: PMT u8vector
              """
              # Split into metadata and data
              meta = pmt.car(msg)
              data = pmt.cdr(msg)

              if not pmt.is_u8vector(data):
                  # Not what we expect; ignore
                  return

              # Convert u8vector to Python bytes
              in_bytes = bytes(bytearray(pmt.u8vector_elements(data)))

              # Prepend ASM
              out_bytes = self._asm + in_bytes

              # Convert back to u8vector
              out_vec = pmt.init_u8vector(len(out_bytes), list(out_bytes))

              # Preserve metadata (you could also modify meta here if needed)
              out_pdu = pmt.cons(meta, out_vec)

              # Publish on output port
              self.message_port_pub(pmt.intern("out"), out_pdu)
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr
      import time
      import threading

      class TestPatternSource_PDU(gr.basic_block):
          """
          Periodically emits PDUs with a simple test pattern:
          [seq_hi][seq_lo][payload bytes...]

          - seq: 16-bit counter
          - payload filled with pattern (e.g. incrementing or 0xAA/0x55)
          """

          def __init__(self, payload_len=200, interval_ms=100):
              gr.basic_block.__init__(self,
                  name="TestPatternSource_PDU",
                  in_sig=None,
                  out_sig=None)

              self.payload_len = int(payload_len)
              self.interval = float(interval_ms) / 1000.0
              self.seq = 0

              self.message_port_register_out(pmt.intern('out'))

              # start worker thread
              self._stop = False
              self.thread = threading.Thread(target=self._worker)
              self.thread.daemon = True
              self.thread.start()

          def stop(self):
              self._stop = True
              try:
                  self.thread.join(timeout=0.1)
              except:
                  pass
              return super().stop()

          def _make_payload(self):
              # 2-byte sequence number + payload_len-2 bytes of pattern
              payload = bytearray(self.payload_len)
              seq = self.seq & 0xFFFF
              payload[0] = (seq >> 8) & 0xFF
              payload[1] = seq & 0xFF

              # simple pattern: incrementing bytes
              for i in range(2, self.payload_len):
                  payload[i] = (i + seq) & 0xFF

              self.seq = (self.seq + 1) & 0xFFFF
              return payload

          def _worker(self):
              while not self._stop:
                  payload = self._make_payload()
                  meta = pmt.make_dict()  # empty metadata

                  vec = pmt.init_u8vector(len(payload), payload)
                  pdu = pmt.cons(meta, vec)

                  self.message_port_pub(pmt.intern('out'), pdu)
                  time.sleep(self.interval)
    interval_ms: '50'
    payload_len: payload_len_int
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy
      import pmt
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Stream block that watches for 'CCSDS_frame' tags and, at the same
          offset, injects a 'frame_len' tag with value 259.

          Assumes:
            - Input and output are uint8 (bytes).
            - Stream is 1:1 passthrough.
          """

          def __init__(self, frame_len=2072):
              gr.sync_block.__init__(
                  self,
                  name="frame_len_from_ccsds_tag",
                  in_sig=[numpy.uint8],
                  out_sig=[numpy.uint8],
              )

              # Keys we'll use
              self.key_ccsds_frame = pmt.intern("CCSDS_frame")
              self.key_frame_len   = pmt.intern("frame_len")
              self.frame_len = pmt.from_long(frame_len)

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]

              # Passthrough
              out[:] = inp

              nread    = self.nitems_read(0)
              nwritten = self.nitems_written(0)
              nitems   = len(inp)

              # Get all tags in this window of input
              tags = self.get_tags_in_window(0, 0, nitems)

              for t in tags:
                  # Only react to CCSDS_frame tags
                  if t.key == self.key_ccsds_frame:
                      # Convert absolute tag offset to relative index within this work() call
                      rel_index = t.offset - nread

                      if 0 <= rel_index < nitems:
                          # Compute absolute output offset for this work() chunk
                          out_offset = nwritten + rel_index

                          # Inject frame_len tag at the same logical position
                          self.add_item_tag(
                              0,                          # output port
                              out_offset,                 # absolute offset on output
                              self.key_frame_len,         # key: "frame_len"
                              self.frame_len,       # value: 259
                              t.srcid                     # preserve original srcid
                          )

              return nitems
    frame_len: '2072'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          PDU block that strips the CCSDS ASM (0x1A CF FC 1D) from each PDU payload.

          Input:  PDU (meta, u8vector) = [ASM(4) + RS(255)]  => 259 bytes
          Output: PDU (same meta, u8vector) = [RS(255)]      => 255 bytes

          If the ASM does not match or PDU is too short, the PDU is dropped.
          """

          def __init__(self, verbose=False):
              gr.basic_block.__init__(
                  self,
                  name="strip_ccsds_asm_pdu",
                  in_sig=None,
                  out_sig=None,
              )

              # CCSDS ASM: 0x1A CF FC 1D
              self._asm = bytes([0x1A, 0xCF, 0xFC, 0x1D])
              self.verbose = verbose

              # Register PDU ports
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.message_port_register_out(pmt.intern("out"))

          def handle_msg(self, msg):
              """
              msg is a PDU: (meta, data)
              meta: PMT dictionary (or PMT_NIL)
              data: PMT u8vector
              """
              meta = pmt.car(msg)
              data = pmt.cdr(msg)

              if not pmt.is_u8vector(data):
                  if self.verbose:
                      print("[strip_ccsds_asm_pdu] Received non-u8vector PDU, dropping.")
                  return

              # Convert u8vector to bytes
              in_bytes = bytes(bytearray(pmt.u8vector_elements(data)))
              length = len(in_bytes)

              if length < 4:
                  if self.verbose:
                      print(f"[strip_ccsds_asm_pdu] PDU too short (len={length}), dropping.")
                  return

              # Check ASM
              asm_bytes = in_bytes[:4]
              if asm_bytes != self._asm:
                  if self.verbose:
                      print(
                          "[strip_ccsds_asm_pdu] ASM mismatch, dropping PDU. "
                          f"Got {asm_bytes.hex()}, expected {self._asm.hex()}"
                      )
                  return
              else: 
                  if self.verbose:
                      print(
                          "[strip_ccsds_asm_pdu] ASM match! "
                          f"Got {asm_bytes.hex()}, expected {self._asm.hex()}"
                      )
                  return

              # Strip ASM, keep remainder (e.g. 255 bytes of RS codeword)
              out_bytes = in_bytes[4:]

              # Convert back to u8vector
              out_vec = pmt.init_u8vector(len(out_bytes), list(out_bytes))

              # Preserve metadata; you could also add a flag here if you want, e.g. asm_ok=True
              out_pdu = pmt.cons(meta, out_vec)

              # Publish on output port
              self.message_port_pub(pmt.intern("out"), out_pdu)
    verbose: 'True'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          PDU block that takes a u8vector of bits (0/1 per element)
          and packs them into bytes (MSB-first).

          Input:  PDU (meta, u8vector) length = 2072 bits
          Output: PDU (meta, u8vector) length = 259 bytes (2072 / 8)
          """

          def __init__(self, verbose=False):
              gr.basic_block.__init__(
                  self,
                  name="bits_to_bytes_pdu",
                  in_sig=None,
                  out_sig=None,
              )

              self.verbose = verbose

              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.message_port_register_out(pmt.intern("out"))

          def handle_msg(self, msg):
              meta = pmt.car(msg)
              data = pmt.cdr(msg)

              if not pmt.is_u8vector(data):
                  if self.verbose:
                      print("[bits_to_bytes_pdu] Non-u8vector PDU, dropping.")
                  return

              bits = list(pmt.u8vector_elements(data))
              n_bits = len(bits)

              if n_bits % 8 != 0:
                  if self.verbose:
                      print(f"[bits_to_bytes_pdu] Bit length {n_bits} not multiple of 8, dropping.")
                  return

              n_bytes = n_bits // 8
              out_bytes = []

              # Pack 8 bits (b0..b7) into one byte: b0 = MSB
              idx = 0
              for _ in range(n_bytes):
                  byte_val = 0
                  for b in range(8):
                      bit = bits[idx]
                      # Ensure bit is 0/1
                      bit = 1 if bit != 0 else 0
                      byte_val = (byte_val << 1) | bit
                      idx += 1
                  out_bytes.append(byte_val)

              out_vec = pmt.init_u8vector(len(out_bytes), out_bytes)
              out_pdu = pmt.cons(meta, out_vec)
              self.message_port_pub(pmt.intern("out"), out_pdu)
    verbose: 'True'
  states: {}
- name: fec_decode_ccsds_27_fb_0
  id: fec_decode_ccsds_27_fb
  parameters: {}
  states: {}
- name: fec_encode_ccsds_27_bb_0
  id: fec_encode_ccsds_27_bb
  parameters: {}
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: '"stream_tag"'
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"frame_len"'
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: post_clock_sync
    size: '2056'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: bpsk_mod
    size: '2056'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    comment: 1,0,1,4
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0,1,4
    type: complex
  states: {}
- name: satellites_decode_rs_0
  id: satellites_decode_rs
  parameters:
    fcr: first_root
    gfpoly: '285'
    interleave: '1'
    nroots: nroots
    nsym: '8'
    prim: prim_element
  states: {state: disabled}
- name: satellites_decode_rs_ccsds_0
  id: satellites_decode_rs_ccsds
  parameters:
    basis: 'False'
    interleave: '1'
  states: {state: disabled}
- name: satellites_encode_rs_0
  id: satellites_encode_rs
  parameters:
    fcr: first_root
    gfpoly: rs_generator
    interleave: '1'
    nroots: nroots
    nsym: '8'
    prim: prim_element
  states: {state: disabled}
- name: satellites_encode_rs_ccsds_0
  id: satellites_encode_rs_ccsds
  parameters:
    basis: 'False'
    interleave: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: clock_sync
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: tag_code
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: encoder_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: clock_sync
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: encoder_out
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: tag_code
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', fec_encode_ccsds_27_bb_0, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_tagged_stream_align_1, '0', blocks_tag_debug_0_0_0, '0']
- [blocks_tagged_stream_align_1, '0', blocks_tag_debug_0_0_0_0, '0']
- [blocks_tagged_stream_align_1, '0', pdu_tagged_stream_to_pdu_0_0_0_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0_0_0_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', fec_decode_ccsds_27_fb_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', virtual_sink_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', virtual_sink_0, '0']
- [epy_block_0, out, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [epy_block_0_0_0, out, satellites_encode_rs_0, in]
- [epy_block_0_0_0, out, satellites_encode_rs_ccsds_0, in]
- [epy_block_1, '0', blocks_tagged_stream_align_1, '0']
- [epy_block_2, out, satellites_decode_rs_ccsds_0, in]
- [epy_block_3, out, blocks_message_debug_0_1_0_0, print]
- [epy_block_3, out, epy_block_2, in]
- [fec_decode_ccsds_27_fb_0, '0', blocks_repack_bits_bb_0_0, '0']
- [fec_encode_ccsds_27_bb_0, '0', virtual_sink_0_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_repack_bits_bb_0, '0']
- [pdu_tagged_stream_to_pdu_0_0_0_0, pdus, epy_block_3, in]
- [satellites_decode_rs_0, out, blocks_message_debug_0_1_0, print]
- [satellites_decode_rs_ccsds_0, out, blocks_message_debug_0_1_0, print]
- [satellites_encode_rs_0, out, epy_block_0, in]
- [satellites_encode_rs_ccsds_0, out, epy_block_0, in]
- [virtual_source_0, '0', digital_costas_loop_cc_0, '0']
- [virtual_source_0_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_0_1, '0', epy_block_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
