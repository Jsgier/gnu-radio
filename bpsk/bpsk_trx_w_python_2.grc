options:
  parameters:
    author: J. Gier
    generate_options: qt_gui
    id: BPSK_Mod_Demod
    output_language: python
    title: BPSK Modulator / Demodulator
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: cc_dec_def
  id: variable_cc_decoder_def
  parameters:
    framebits: frame_bits
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'True'
    polys: '[121,91]'
    rate: '2'
    state_end: '0'
    state_start: '0'
  states: {}
- name: cc_enc_def
  id: variable_cc_encoder_def
  parameters:
    framebits: frame_bits
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'True'
    polys: '[121,91]'
    rate: '2'
    state_start: '0'
  states: {}
- name: decode_bits
  id: variable
  parameters:
    value: int(frame_bits/8)
  states: {}
- name: delay
  id: variable
  parameters:
    value: int((1.875*sps+7)*2)
  states: {}
- name: depth
  id: variable
  parameters:
    value: '2'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.350'
  states: {}
- name: first_root
  id: variable
  parameters:
    value: '1'
  states: {}
- name: frame_bits
  id: variable
  parameters:
    value: frame_bytes*8
  states: {}
- name: frame_bytes
  id: variable
  parameters:
    value: payload_coded_len* depth
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Freq Offset'
    start: '-100e-2 * (1/samp_rate)'
    step: 10e-2 * (1/samp_rate)
    stop: 100e-2 * (1/samp_rate)
    value: '0'
  states: {}
- name: gen_poly
  id: variable
  parameters:
    value: '285'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"payload_coded_len"'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '100e-3'
    stop: '500e-3'
    value: '10E-3'
  states: {}
- name: nroots
  id: variable
  parameters:
    value: '32'
  states: {}
- name: packet_len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: payload_coded_len
  id: variable
  parameters:
    value: payload_len_int + 32
  states: {}
- name: payload_len_int
  id: variable
  parameters:
    value: '200'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: 2*3.14/200
  states: {}
- name: prim_element
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 11*sps*nfilts)
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1, samp_rate, samp_rate/sps, excess_bw, 11*sps)
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    label: 'Channel: time offset'
    start: '0.999'
    step: '100e-6'
    stop: '1.001'
    value: '1'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_1_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: 232 bytes in, 1856 bits out (as bytes)
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"frame_len"'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: 1856 bits in (as bytes), 232 bytes out
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"frame_len"'
  states: {}
- name: blocks_repack_bits_bb_2
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: payload_len_int
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: len_tag_key
    name: '"test"'
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle2_0_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    use_snr: 'True'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '16'
    init_phase: '8'
    loop_bw: excess_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr
      import time
      import threading

      class TestPatternSource_PDU(gr.basic_block):
          """
          Periodically emits PDUs with a simple test pattern:
          [seq_hi][seq_lo][payload bytes...]

          - seq: 16-bit counter
          - payload filled with pattern (e.g. incrementing or 0xAA/0x55)
          """

          def __init__(self, payload_len=200, interval_ms=100):
              gr.basic_block.__init__(self,
                  name="TestPatternSource_PDU",
                  in_sig=None,
                  out_sig=None)

              self.payload_len = int(payload_len)
              self.interval = float(interval_ms) / 1000.0
              self.seq = 0

              self.message_port_register_out(pmt.intern('out'))

              # start worker thread
              self._stop = False
              self.thread = threading.Thread(target=self._worker)
              self.thread.daemon = True
              self.thread.start()

          def stop(self):
              self._stop = True
              try:
                  self.thread.join(timeout=0.1)
              except:
                  pass
              return super().stop()

          def _make_payload(self):
              # 2-byte sequence number + payload_len-2 bytes of pattern
              payload = bytearray(self.payload_len)
              seq = self.seq & 0xFFFF
              payload[0] = (seq >> 8) & 0xFF
              payload[1] = seq & 0xFF

              # simple pattern: incrementing bytes
              for i in range(2, self.payload_len):
                  payload[i] = (i + seq) & 0xFF

              self.seq = (self.seq + 1) & 0xFFFF
              return payload

          def _worker(self):
              while not self._stop:
                  payload = self._make_payload()
                  meta = pmt.make_dict()  # empty metadata

                  vec = pmt.init_u8vector(len(payload), payload)
                  pdu = pmt.cons(meta, vec)

                  self.message_port_pub(pmt.intern('out'), pdu)
                  time.sleep(self.interval)
    interval_ms: '100'
    payload_len: payload_len_int
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr
      import reedsolo

      class RS223_255_Deinterleave_Dec_PDU(gr.basic_block):
          """
          Input PDU: interleaved RS(223,255) codewords (bytes)
          Output PDU: deinterleaved & RS-decoded bytes (original before RS+interleave)

          Assumes same interleaver depth as encoder.
          """
          def __init__(self, depth=5):
              gr.basic_block.__init__(self,
                  name="RS223_255_Deinterleave_Dec_PDU",
                  in_sig=None,
                  out_sig=None)

              self.depth = int(depth)
              self.rs = reedsolo.RSCodec(32)

              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.handle_pdu)
              self.message_port_register_out(pmt.intern('out'))

          def _deinterleave(self, data):
              """
              Inverse of encoder's _interleave.
              Returns a list of 255-byte codewords.
              """
              if self.depth <= 1:
                  # no interleaving
                  if len(data) % 255 != 0:
                      # truncate partial
                      data = data[:len(data) - (len(data) % 255)]
                  codewords = []
                  for i in range(0, len(data), 255):
                      codewords.append(bytearray(data[i:i+255]))
                  return codewords

              cw_len = 255
              group_size = self.depth * cw_len
              codewords = []

              idx = 0
              while idx + group_size <= len(data):
                  group_bytes = data[idx:idx + group_size]
                  idx += group_size

                  # reconstruct matrix: columns x rows
                  # we read out in columns: for each col, depth rows
                  # So we fill matrix[col][row]
                  matrix = [[0 for _ in range(self.depth)] for _ in range(cw_len)]
                  p = 0
                  for col in range(cw_len):
                      for row in range(self.depth):
                          matrix[col][row] = group_bytes[p]
                          p += 1

                  # Now read out row-wise to get codewords
                  for row in range(self.depth):
                      cw = bytearray(cw_len)
                      for col in range(cw_len):
                          cw[col] = matrix[col][row]
                      codewords.append(cw)

              return codewords

          def _decode_blocks(self, codewords):
              out = bytearray()
              for cw in codewords:
                  try:
                      dec = self.rs.decode(bytes(cw))  # returns original 223 bytes
                      out.extend(dec)
                  except reedsolo.ReedSolomonError:
                      # drop or append zeros on failure; here we drop
                      pass
              return out

          def handle_pdu(self, pdu):
              meta = pmt.car(pdu)
              data = bytearray(pmt.u8vector_elements(pmt.cdr(pdu)))

              codewords = self._deinterleave(data)
              decoded = self._decode_blocks(codewords)

              out_vec = pmt.init_u8vector(len(decoded), decoded)
              out_pdu = pmt.cons(meta, out_vec)
              self.message_port_pub(pmt.intern('out'), out_pdu)
    depth: depth
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr
      import sys

      class TestPatternChecker_PDU(gr.basic_block):
          """
          Checks received PDUs against the known test pattern:

          Input PDU payload format:
              [seq_hi][seq_lo][pattern bytes...]

          - seq = 16-bit sequence number
          - pattern[i] = (i + seq) & 0xFF for i >= 2

          It:
            * Recomputes expected payload for that seq
            * Compares byte-by-byte
            * Tracks total frames, bad frames, and total byte errors
            * Prints stats to stdout if verbose=True
          """

          def __init__(self, expected_len=200, verbose=True):
              gr.basic_block.__init__(self,
                  name="TestPatternChecker_PDU",
                  in_sig=None,
                  out_sig=None)

              self.expected_len = int(expected_len)
              self.verbose = bool(verbose)

              self.total_frames = 0
              self.bad_frames = 0
              self.total_byte_errors = 0

              # one input PDU port called "in"
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.handle_pdu)

          def _expected_payload(self, seq):
              """
              Reconstruct the expected payload for a given sequence number.
              Must match whatever TestPatternSource_PDU generates.
              """
              payload = bytearray(self.expected_len)
              payload[0] = (seq >> 8) & 0xFF
              payload[1] = seq & 0xFF
              for i in range(2, self.expected_len):
                  payload[i] = (i + seq) & 0xFF
              return payload

          def handle_pdu(self, pdu):
              meta = pmt.car(pdu)
              data = bytearray(pmt.u8vector_elements(pmt.cdr(pdu)))

              if len(data) < 2:
                  # too short to contain seq
                  return

              # If RS or padding changed the length, you can either:
              #  - enforce exact length
              #  - or compare up to min(len(data), expected_len)
              if len(data) != self.expected_len:
                  if self.verbose:
                      sys.stdout.write(
                          "Checker: length mismatch (rx=%d, expected=%d)\n"
                          % (len(data), self.expected_len)
                      )
                      sys.stdout.flush()
                  # use the common subset for comparison
                  compare_len = min(len(data), self.expected_len)
                  data = data[:compare_len]
              else:
                  compare_len = len(data)

              seq = (data[0] << 8) | data[1]
              expected = self._expected_payload(seq)[:compare_len]

              self.total_frames += 1

              byte_errors = 0
              for i in range(compare_len):
                  if data[i] != expected[i]:
                      byte_errors += 1

              if byte_errors > 0:
                  self.bad_frames += 1
                  self.total_byte_errors += byte_errors

              if self.verbose:
                  sys.stdout.write(
                      "Frame %d (seq=%d): len=%d, byte_errors=%d, "
                      "bad_frames=%d/%d, total_byte_errors=%d\n"
                      % (self.total_frames, seq, compare_len,
                         byte_errors, self.bad_frames,
                         self.total_frames, self.total_byte_errors)
                  )
                  sys.stdout.flush()
    expected_len: payload_len_int
    verbose: 'True'
  states: {state: disabled}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    comment: 11 Puncture Patttern -> both encoded output bits always kept
    decoder_list: cc_dec_def
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_0_0
  id: fec_extended_encoder
  parameters:
    comment: 11 Puncture Patttern -> both encoded output bits always kept
    encoder_list: cc_enc_def
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'Source: https://wiki.gnuradio.org/index.php?title=QPSK_Mod_and_Demod#Objectives'
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: '"frame_len"'
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: len_tag_key
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"frame_len"'
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: post_rrc2
    size: '2056'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: pre_channel
    size: '2056'
    type: complex
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '10'
    size: '1024'
    type: float
    xmax: '1.5'
    xmin: '-0.5'
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: byte
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: byte
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: satellites_decode_rs_0_0
  id: satellites_decode_rs
  parameters:
    comment: 232 bytes in, 200 bytes out
    fcr: first_root
    gfpoly: gen_poly
    interleave: '1'
    nroots: nroots
    nsym: '8'
    prim: prim_element
  states: {}
- name: satellites_encode_rs_0_0
  id: satellites_encode_rs
  parameters:
    comment: 200 bytes in, 232 bytes out
    fcr: first_root
    gfpoly: gen_poly
    interleave: '1'
    nroots: nroots
    nsym: '8'
    prim: prim_element
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: fec
  states: {state: disabled}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: fec_enc
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {}
- name: virtual_sink_2_0_0
  id: virtual_sink
  parameters:
    stream_id: fec_dec
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: r2
  states: {state: disabled}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: fec_enc
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_1_0_1
  id: virtual_source
  parameters:
    stream_id: fec_dec
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_constellation_modulator_0_0, '0']
- [analog_random_source_x_0, '0', qtgui_number_sink_0_0_0_0, '0']
- [blocks_char_to_float_0, '0', virtual_sink_2_0_0, '0']
- [blocks_char_to_float_1, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', fec_extended_encoder_0_0, '0']
- [blocks_repack_bits_bb_1, '0', virtual_sink_1_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0_0, '0']
- [blocks_repack_bits_bb_2, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tag_debug_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_throttle2_0_0_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle2_0_0_0_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [channels_channel_model_0_0, '0', virtual_sink_2_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', blocks_char_to_float_1, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', qtgui_number_sink_0_0_0, '0']
- [digital_constellation_modulator_0, '0', channels_channel_model_0_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0_0_0_0_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0_0_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0_0_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [epy_block_0_0_0, out, satellites_encode_rs_0_0, in]
- [epy_block_2, out, blocks_message_debug_0, print]
- [epy_block_2, out, epy_block_3, in]
- [fec_extended_decoder_0_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [fec_extended_encoder_0_0, '0', virtual_sink_2, '0']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_2, in]
- [pdu_tagged_stream_to_pdu_0_0_0_0, pdus, satellites_decode_rs_0_0, in]
- [satellites_decode_rs_0_0, out, blocks_message_debug_0_1_0, print]
- [satellites_encode_rs_0_0, out, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [virtual_source_1, '0', blocks_repack_bits_bb_2, '0']
- [virtual_source_1_0, '0', blocks_throttle2_0_0_0, '0']
- [virtual_source_1_0_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [virtual_source_1_0_1, '0', fec_extended_decoder_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
